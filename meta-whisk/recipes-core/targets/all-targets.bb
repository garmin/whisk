SUMMARY = "Main build target"

inherit build-alias

TARGETS = "${WHISK_TARGETS_core}"

